IMAGE_INSTALL += "dropbear cpp-sample"
